# Keil uVision project STM32VET6.uvproj, settings and files
target STM32VET6 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: STM32VET6
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\FWlib\inc;.\Drivers;..\CMSIS;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartupCode
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group User
    ./: main.c exti.c stm32f10x_conf.h stm32f10x_it.c SysTick.c led.c Timer.c st7920.c key.c adc.c Display.c SPWM.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c
